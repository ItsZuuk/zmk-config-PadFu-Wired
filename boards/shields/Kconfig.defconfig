## boards/shields/PadFuHedge/Kconfig.defconfig
```kconfig
if SHIELD_PADFUHEDGE

config ZMK_KEYBOARD_NAME   
    default "PadFuHedge"

endif
```
